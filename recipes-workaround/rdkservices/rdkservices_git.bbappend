PACKAGECONFIG:remove = " xcast"
